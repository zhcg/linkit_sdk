# Keil uVision project sleep_manager_power_mode.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MT7687F MediaTek
  pack: MediaTek.MTx.4.5.0
  cpu: IROM(0x10000000,0x00400000) IRAM(0x20000000,0x00040000) IRAM2(0x00100000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sleep_manager_power_mode
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  AfterMake: fromelf.exe -c -o $L@L.dis #L
  c flags: Optim=4 OneElfS=1 wLevel=2
  c misc: --c99
  c include: ..\..\..\..\..\driver\board\linkit7697_hdk\external_flash\inc;..\..\..\..\..\middleware\MTK\connsys\inc;..\inc;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\chip\mt7687\inc;..\..\..\..\..\driver\chip\mt7687\src\common\include;..\..\common\inc;..\..\..\..\..\middleware\third_party\lwip\ports\include;..\..\..\..\..\middleware\third_party\lwip\src\include\lwip;..\..\..\..\..\middleware\MTK\verno\inc
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  scatter file: .\flash.sct
  link misc: --entry Reset_Handler --first __isr_vector
  group app
    ../src/: main.c
  group driver
    ../../../../../driver/chip/mt7687/src/common/: top.c nvic.c hal_gpio_7687.c low_hal_gpio.c pinmux.c hal_pinmux.c low_hal_pwm.c pwm.c uart.c dma.c flash_sfc.c sfc.c spi_flash.c timer.c gpt.c hal_lp.c
    ../../../../../driver/chip/mt7687/src/: hal_log.c hal_gpio.c hal_pwm.c hal_uart.c hal_cache.c hal_cache_internal.c hal_nvic_internal.c hal_nvic.c hal_gpt.c hal_misc.c
    ../../../../../prebuilt/driver/chip/mt7687/lib/: libhal_core_CM4_Keil.lib
    ../../../../../driver/board/linkit7697_hdk/external_flash/src/: bsp_flash_config.c
  group cmsis
    ./: startup_mt7687.s
    ../src/: system_mt7687.c
