# Keil uVision project des_encrypt_decrypt_data.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MT7687F MediaTek
  pack: MediaTek.MTx.4.5.0
  cpu: IROM(0x10000000,0x00200000) IRAM(0x20000000,0x00040000) IRAM2(0x00100000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: des_encrypt_decrypt_data
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  AfterMake: fromelf.exe -c -o $L@L.dis #L
  c flags: Optim=4 OneElfS=1 wLevel=2
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\chip\mt7687\inc;..\..\..\..\..\driver\chip\mt7687\src\common\include;..\..\common\inc;..\..\..\..\..\middleware\MTK\verno\inc
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  scatter file: .\flash.sct
  link misc: --entry Reset_Handler --first __isr_vector
  group app
    ../src/: main.c
  group driver
    ../../../../../driver/chip/mt7687/src/common/: top.c dma.c hal_gpio_7687.c hal_pinmux.c low_hal_gpio.c nvic.c pinmux.c uart.c gpt.c timer.c
    ../../../../../driver/chip/mt7687/src/: hal_des.c hal_gpio.c hal_log.c hal_uart.c hal_aes.c hal_gpt.c hal_nvic.c hal_nvic_internal.c
  group cmsis
    ./: startup_mt7687.s
    ../src/: system_mt7687.c
  group lib
    ../../../../../prebuilt/driver/chip/mt7687/lib/: libhal_protected_CM4_Keil.lib
