# Keil uVision project minicli.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MT7687F MediaTek
  pack: MediaTek.MTx.4.5.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00100000,0x00010000) IROM(0x10000000,0x00400000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: minicli
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  AfterMake: fromelf.exe -c -o $L@L.dis #L
  c flags: Optim=4 OneElfS=1
  c define: MTK_DEBUG_LEVEL_INFO  PRODUCT_VERSION=7687 CFG_SUPPORT_SMNT_PROTO=2
  c misc: --c99 --diag_suppress=161 --diag_suppress=1295
  c include: ..\inc;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\driver\chip\mt7687\inc;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include;..\..\..\..\..\driver\chip\mt7687\src\common\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\driver\board\mt76x7_hdk\ept\inc;..\..\..\..\..\middleware\MTK\minicli\inc;..\..\..\..\..\driver\board\mt76x7_hdk\util\inc;..\..\..\..\..\middleware\MTK\wifi_service\combo\inc;..\..\..\..\..\driver\board\mt76x7_hdk\external_flash\inc;..\..\..\..\..\middleware\MTK\connsys\inc;..\..\..\..\..\middleware\MTK\verno\inc
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  scatter file: .\flash.sct
  link misc: --entry Reset_Handler --first __isr_vector --keep N9_array
  group apps
    ../src/: main.c regions_init.c sys_init.c ept_eint_var.c ept_gpio_var.c
    ../../../../../tools/keil/mt7687/N9/: mt76X7_n9_image.c
  group cmsis
    ../src/: system_mt7687.c
    ./: startup_mt7687.s
  group driver
    ../../../../../driver/chip/mt7687/src/: hal_misc.c hal_cache.c hal_cache_internal.c hal_des.c hal_eint.c hal_flash.c hal_gdma.c hal_gpio.c hal_gpt.c hal_i2c_master.c hal_i2s.c hal_irtx.c hal_log.c hal_md5.c hal_nvic.c hal_dwt.c hal_nvic_internal.c hal_pwm.c hal_rtc.c hal_sha.c hal_spi_master.c hal_uart.c hal_wdt.c hal_spi_slave.c hci_log.c hal_adc.c hal_aes.c
    ../../../../../driver/chip/mt7687/src/common/: cos_api.c dma.c flash_sfc.c gpt.c hal_gpc.c hal_gpio_7687.c hal_I2C.c hal_i2s_internal.c hal_irrx.c hal_pcnt.c hal_pinmux.c hal_spim.c hal_sys.c hal_trng.c hal_uid.c i2c.c ir_tx.c low_hal_gpio.c low_hal_irrx.c low_hal_irtx.c low_hal_pwm.c low_hal_rtc.c low_hal_wdt.c nvic.c pinmux.c pwm.c sfc.c spi_flash.c spim.c timer.c top.c uart.c hal_lp.c
    ../../../../../driver/board/mt76x7_hdk/external_flash/src/: bsp_flash_config.c
  group rtos
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/mt7687/: port_tick.c
    ../../../../../kernel/rtos/FreeRTOS/Source/: timers.c event_groups.c list.c queue.c tasks.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group service
    ../../../../../kernel/service/src/: context_info_save.c exception_handler.c syslog.c toi.c os_port_callback.c
  group lib
    ../../../../../prebuilt/driver/chip/mt7687/lib/: libhal_core_CM4_Keil.lib libhal_protected_CM4_Keil.lib
    ../../../../../prebuilt/middleware/MTK/minicli/lib/: libminicli_CM4_Keil.lib
  group board
    ../../../../../driver/board/mt76x7_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../middleware/MTK/wifi_service/combo/src/wifi_os_ext/: os_util.c os_utils.c
    ../../../../../driver/board/mt76x7_hdk/util/src/: io_def.c
  group middleware
    ../../../../../middleware/MTK/minicli/src/: minicli_api.c
